# Keil uVision project AudioPlayer.uvproj, settings and files
target HY-Smart (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: AudioPlayer
  c flags: Optim=1
  c define: STM32F10X_HD
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Headers
    ./: system_stm32f10x.h
  group Source
    ./: main.c startup_stm32f10x_hd.s system_stm32f10x.c
